# IAR project Backup of SerialDongle.ewp, settings and files
configuration CoordinatorEB (8051, debug)
  General.DerivativeDescriptionFile: $TOOLKIT_DIR$\config\devices\Texas Instruments\CC2530F256.i51
  ICC8051.CCDefines: ZDO_MGMT_LQI_RESPONSE; HAL_PA_LNA; SECURE=1; OSALMEM_METRICS; REFLECTOR; xPOWER_SAVE; HAL_KEY=0; TC_LINKKEY_JOIN; REFLECTOR; NV_INIT; NV_RESTORE; xHOLD_AUTO_START; xZTOOL_P1; xMT_TASK; xMT_APP_FUNC; xMT_SYS_FUNC; xMT_ZDO_FUNC; MULTICAST_ENABLED=FALSE; ZCL_READ; ZCL_WRITE; ZCL_REPORT; ZCL_EZMODE; ZCL_BASIC; ZCL_IDENTIFY; ZCL_ON_OFF; ZCL_DIAGNOSTIC; FEATURE_SYSTEM_STATS
  ICC8051.CCDiagSuppress: Pe001,Pa010
  ICC8051.OCCDataMemoryModel: 1
  ICC8051.OCCCodeMemoryModel: 1
  ICC8051.CCIncludePath2: $PROJ_DIR$; ..\Source; ..\Source\ha; ..\Source\zmain; ..\Components\hal\include; ..\Components\hal\target\CC2530EB; ..\Components\hal\target\CC2531_USBDONGLE; ..\Components\hal\target\CC2530USB\usb\class_UsbCoordinator; ..\Components\hal\target\CC2530USB\usb\library; ..\Components\hal\target\CC2530USB\usb\library\cc2531; ..\Components\mac\include; ..\Components\mac\high_level; ..\Components\mac\low_level\srf04; ..\Components\mac\low_level\srf04\single_chip; ..\Components\mt; ..\Components\osal\include; ..\Components\services\saddr; ..\Components\services\sdata; ..\Components\stack\af; ..\Components\stack\nwk; ..\Components\stack\sapi; ..\Components\stack\sec; ..\Components\stack\sys; ..\Components\stack\zcl; ..\Components\stack\zdo; ..\Components\zmac; ..\Components\zmac\f8w
  ICC8051.CCOptLevel: 0
  ICC8051.CCOptStrategy: 1
  ICC8051.IccLang: 0
  XLINK.XclFile: ..\Tools\f8w2530.xcl
configuration Coordinator2592 (8051, debug)
  as the first configuration, except:
  ICC8051.CCDefines: ZDO_MGMT_LQI_RESPONSE; HAL_PA_LNA_CC2592; SECURE=1; OSALMEM_METRICS; REFLECTOR; xPOWER_SAVE; HAL_KEY=0; TC_LINKKEY_JOIN; REFLECTOR; NV_INIT; NV_RESTORE; xHOLD_AUTO_START; xZTOOL_P1; xMT_TASK; xMT_APP_FUNC; xMT_SYS_FUNC; xMT_ZDO_FUNC; MULTICAST_ENABLED=FALSE; ZCL_READ; ZCL_WRITE; ZCL_REPORT; ZCL_EZMODE; ZCL_BASIC; ZCL_IDENTIFY; ZCL_ON_OFF; ZCL_DIAGNOSTIC; FEATURE_SYSTEM_STATS
  ICC8051.CCOptLevel: 3
  ICC8051.CCOptStrategy: 2
  group App/Serial
    ../Source/: CheckingChildList.c CheckingChildList.h dmaIRQ.c endpointRequestList.c endpointRequestList.h OSAL_Coordinator.c TimerEvents.h zcl_functions.c zcl_functions.h ZdoMessageHandlers.c ZdoMessageHandlers.h zigbee_functions.c zigbee_functions.h ZigBeeSerialBridge.c ZigBeeSerialBridge.h ZigbeeSerialBridge_data.h
    ../Tools/: f8wCoord.cfg
  group App/Serial/SerialReceive
    ../Source/SerialReceive/: DecodingFunctions.h GetIEEEAddress.c GetMgmtLqiReq.c GetNodeDescriptor.c Init.c InvalidCmd.c RemoveDevice.c RequestActiveEndpoints.c RequestAttribute.c requestAttributes.c RequestBindTable.c RequestNodePower.c RequestReset.c SendCmd.c SendReqBind.c SendReqDeviceInfo.c SerialProcessEvent.c SerialReceive.c SerialReceive.h WriteAttribute.c
  group App/Serial/SerialSend
    ../Source/SerialSend/: MgmtLqiResponseMessage.c NodeDescriptionResponseMessage.c NodeDescriptorResponseMessageError.c NodePowerResponseMessage.c NodePowerResponseMessageError.c SendActiveEP_Error.c SendAlive.c sendDeviceInfo.c SendMessage.c SendMethods.c SendMethods.h SerialSend.c SerialSend.h SerialSendAnnunce.c serialSendAttributeResponseMsg.c SerialSendAttributeResponseMsgError.c SerialSendBindTable.c SerialSendIeeeAddress.c SerialSendSimpleDescriptor.c SerialSendWriteAttributeError.c
  group HAL/Common
    ../Components/hal/common/: hal_assert.c hal_drivers.c
  group HAL/Include
    ../Components/hal/include/: hal_adc.h hal_assert.h hal_board.h hal_defs.h hal_drivers.h hal_flash.h hal_key.h hal_lcd.h hal_led.h hal_rpc.h hal_sleep.h hal_timer.h hal_uart.h
    ../Components/hal/target/CC2531_USBDONGLE/: hal_board_cfg.h
  group HAL/Target/CC2530EB/Drivers
    ../Components/hal/target/CC2530EB/: hal_adc.c hal_dma.c hal_flash.c hal_key.c hal_lcd.c hal_led.c hal_sleep.c hal_startup.c hal_timer.c
  group HAL/Target/CC2530EB/Includes
    ../Components/hal/target/CC2530EB/: hal_aes.h hal_ccm.h hal_dma.h hal_mcu.h hal_types.h
  group HAL/Target/CC2531_USBDONGLE
    ../Components/hal/target/CC2531_USBDONGLE/: hal_usbdongle_cfg.c hal_usbdongle_cfg.h
  group MAC/High Level
    ../Components/mac/high_level/: mac_cfg.c mac_high_level.h mac_pib.c mac_pib.h mac_spec.h
  group MAC/Include
    ../Components/mac/include/: mac_api.h
  group MAC/Low Level/Common
    ../Components/mac/low_level/srf04/: mac_assert.h mac_autopend.c mac_autopend.h mac_backoff_timer.c mac_backoff_timer.h mac_low_level.c mac_low_level.h mac_radio.c mac_radio.h mac_rx.c mac_rx.h mac_rx_onoff.c mac_rx_onoff.h mac_sleep.c mac_sleep.h mac_tx.c mac_tx.h
  group MAC/Low Level/System
    ../Components/mac/low_level/srf04/single_chip/: mac_csp_tx.c mac_csp_tx.h mac_mcu.c mac_mcu.h mac_mem.c mac_mem.h mac_radio_defs.c mac_radio_defs.h mac_rffrontend.c
  group NWK
    ../Components/stack/nwk/: AddrMgr.h APS.h aps_frag.h aps_groups.h aps_util.h APSMEDE.h AssocList.h BindingTable.c BindingTable.h bindTable2.c bindTable2.h NLMEDE.h nwk.h nwk_bufs.h nwk_globals.c nwk_globals.h nwk_util.h reflecttrack.h rtg.h stub_aps.c stub_aps.h
    ../Components/stack/sapi/: sapi.c sapi.h
    ../Components/stack/sys/: ZDiags.c ZDiags.h ZGlobals.c ZGlobals.h
  group OSAL
    ../Components/osal/include/: comdef.h osal.h OSAL_Clock.h OSAL_Memory.h OSAL_Nv.h OSAL_PwrMgr.h osal_task.h OSAL_Tasks.h OSAL_Timers.h ZComDef.h
    ../Components/osal/common/: OSAL.c OSAL_Clock.c OSAL_Memory.c OSAL_PwrMgr.c OSAL_Timers.c
    ../Components/osal/mcu/cc2530/: OSAL_Math.s51 OSAL_Nv.c
    ../Source/: OSAL_Memory2.c
  group Profile
    ../Components/stack/af/: AF.c AF.h
    ../Components/stack/zcl/: zcl.c zcl.h zcl_diagnostic.c zcl_diagnostic.h zcl_ezmode.c zcl_ezmode.h zcl_general.c zcl_general.h zcl_LinkQuality.c zcl_LinkQuality.h
    ../Source/ha/: zcl_ha.c zcl_ha.h
  group Security
    ../Components/stack/sec/: ssp.h ssp_hash.h
  group Services
    ../Components/services/saddr/: saddr.c saddr.h
  group Tools
    ../Tools/: f8w2530.xcl f8wConfig.cfg f8wConfig_test.cfg f8wEndev.cfg f8wRouter.cfg f8wZCL.cfg
  group ZDO
    ../Components/stack/zdo/: ZDApp.c ZDApp.h ZDConfig.c ZDConfig.h ZDNwkMgr.c ZDNwkMgr.h ZDObject.c ZDObject.h ZDProfile.c ZDProfile.h ZDSecMgr.c ZDSecMgr.h
  group ZMac
    ../Components/zmac/f8w/: zmac.c zmac_cb.c zmac_internal.h
    ../Components/zmac/: ZMAC.h
  group ZMain
    ../Source/zmain/: chipcon_cstartup.s51 OnBoard.c OnBoard.h ZMain.c
