<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\SerialDongle.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>ALL</name>
      <member>
        <project>SerialDongle</project>
        <configuration>CoordinatorEB</configuration>
      </member>
     </batchDefinition>
  </batchBuild>
</workspace>


